# Keil uVision project udp_demo.uvprojx, settings and files
target udp_demo (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: udp_demo +hex
  AfterMake: ..\..\tool\after_build.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c misc: --C99
  c include: ../Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/posix; ../Middlewares/Third_Party/LwIP/src/include/posix/sys; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include; ..\..\bootloader\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: lcp.c vj.c ppp.c pppapi.c pppoe.c ipv6cp.c auth.c demand.c upap.c multilink.c utils.c pppcrypt.c ecp.c chap-new.c eap.c eui64.c fsm.c chap-md5.c ccp.c mppe.c chap_ms.c ipcp.c pppol2tp.c pppos.c magic.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c nd6.c ethip6.c ip6_frag.c icmp6.c inet6.c ip6.c mld6.c ip6_addr.c
    ../Middlewares/Third_Party/LwIP/src/api/: netdb.c api_msg.c tcpip.c api_lib.c netifapi.c err.c sockets.c netbuf.c
    ../Middlewares/Third_Party/LwIP/src/core/: def.c init.c memp.c sys.c netif.c tcp.c ip.c dns.c stats.c tcp_in.c udp.c raw.c inet_chksum.c timeouts.c pbuf.c tcp_out.c mem.c
    ../Middlewares/Third_Party/LwIP/src/netif/: slipif.c lowpan6.c ethernet.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_frag.c icmp.c autoip.c ip4.c igmp.c etharp.c dhcp.c ip4_addr.c
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_eth.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_spi.c
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c lwip.c stm32f1xx_it.c ethernetif.c main.c app_ethernet.c delay.c modbus_crc.c modbus_udp.c spi_lcd.c udp_echoclient.c user_flash.c user_io.c user_spi.c user_time.c user_uart.c user_boot.c
    ../Inc/: user_config.h
software components: CMSIS:CORE 4.1.0
